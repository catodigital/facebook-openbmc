#
# These file add version

# Machine name and BMC version for release
MACHINE_NAME = "Yosemite"
BMC_VERSION = "0.9.0"

# Replace PRETTY_NAME to add MACHINE_NAME and BMC_VERSION
PRETTY_NAME = "CatoDigital(1.2) ${MACHINE_NAME} ${BMC_VERSION} -- Base: ${DISTRO_NAME} ${VERSION}"
